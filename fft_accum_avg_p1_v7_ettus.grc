<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fft_accum_avg_p1_rts_2048_ettus</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_to_avg</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_c</value></param>
<param><key>value</key><value>106.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_start</value></param>
<param><key>value</key><value>90.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_stop</value></param>
<param><key>value</key><value>150.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_FFTs</value></param>
<param><key>value</key><value>(f_stop-f_start)/samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_head</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>str_file_out</value></param>
<param><key>value</key><value>'/Users/josaitis/gnuradio_tutorials/fft_accum_temp/fft_accum_temp_TEST.txt'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
<param><key>vlen</key><value>vec_fft_len</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>str_file_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>vec_fft_len</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>n_head</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>vec_fft_len</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>vec_fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(vec_fft_len)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>source_to_fft_vector</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_fft_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>f_c</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>12</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source_to_fft_vector</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>source_to_fft_vector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
